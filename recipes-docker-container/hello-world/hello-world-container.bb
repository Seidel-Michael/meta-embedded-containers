SUMMARY = "Hello World Docker Container"
LICENSE = "MIT"

REGISTRY = "registry.hub.docker.com"
UNAME = "library"
IMAGE = "hello-world"
SHAHASH = "sha256:50b8560ad574c779908da71f7ce370c0a2471c098d44d1c8f6b513c5a55eeeb1"
TAG = "latest"

inherit docker-container

